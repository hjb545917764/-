# Keil uVision project NXP_Car.uvprojx, settings and files
target MK60DN512 (5060020::V5.06 (build 20)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: NXP_Car +hex
  c flags: Optim=1 wLevel=2
  c define: MK60D10 RAVEN DEBUG
  c misc: --c99
  c include: ..\..\Libraries\drivers\inc;..\inc;..\..\Libraries\devices\inc;..\..\Libraries\fatfs;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group user
    ../src/: main.c
  group function
    ../src/: camera.c Running.c delay.c Img_processing.c Init.c Car_Test.c Motor.c ov7620.c switch.c variable.c Move.c
  group startup
    ../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group drivers
    ../../Libraries/drivers/src/: adc.c cmt.c common.c dac.c dma.c ftm.c gpio.c io2iic.c pit.c sd.c systick.c uart.c wdog.c spi.c flash.c
  group device
    ../../Libraries/devices/src/: Drv_LCD.c ov7725.c
  group fatfs
    ../../Libraries/fatfs/: diskio.c ff.c
